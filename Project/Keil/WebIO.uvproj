# Keil uVision project WebIO.uvproj, settings and files
target WebIO (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WebIO +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Source\App\Head;..\..\Source\HAL\Evm\Head;..\..\Source\HAL\Oled;..\..\Source\HAL\Io;..\..\Source\LM3S_Lib;..\..\Source\LM3S_Lib\inc;..\..\Source\LM3S_Lib\DriverLib;..\..\Source\lwip-1.3.2\ports\stellaris\include;..\..\Source\lwip-1.3.2\src\include;..\..\Source\lwip-1.3.2\src\include\ipv4;..\..\Source\lwipConfig;..\..\Source\Utils\Head;..\..\Source\WebServer;..\..\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Application
    ../../Source/App/Src/: main.c temperature_sensor.c
  group HAL
    ../../Source/HAL/: Startup_rvmdk.s
    ../../Source/HAL/Oled/: rit128x96x4.c
    ../../Source/HAL/IO/: Io.c
  group Lwip-port
    ../../Source/lwip-1.3.2/ports/stellaris/: sys_arch.c perf.c
    ../../Source/lwip-1.3.2/ports/stellaris/netif/: stellarisif.c
  group Lwip-src-api
    ../../Source/lwip-1.3.2/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
  group Lwip-src-core
    ../../Source/lwip-1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
  group Lwip-src-core-ipv4
    ../../Source/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_frag.c ip_addr.c
  group Lwip-src-core-snmp
    ../../Source/lwip-1.3.2/src/core/snmp/: msg_out.c asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c
  group Lwip-src-netif
    ../../Source/lwip-1.3.2/src/netif/: loopif.c etharp.c
  group Lwip-src-netif-ppp
    ../../Source/lwip-1.3.2/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group Lwip-config
    ../../Source/lwipConfig/: locator.c lwiplib.c
  group WebServer
    ../../Source/WebServer/: lmi_fs.c httpd.c cgifuncs.c
  group Utils
    ../../Source/Utils/Src/: ustdlib.c uartstdio.c
  group LM3S_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
